# Repository goat-hill/bitclock

File README.md:

# bitclock
Open source e-ink desk companion, clock, and air quality monitor.

Available for purchase in USA @ https://bitclock.io

Visit https://bitclock.io/connect to configure your existing device

## Firmware

Source code for ESP32 using the ESP-IDF development framework.

See [bitclock-fw/](bitclock-fw/)

## Website

Next.js web app for [homepage](https://bitclock.io) and [device configurator](https://bitclock.io/connect).

See [bitclock-web/](bitclock-web/)

## Enclosure

OnShape design, STEP files, and instructions for 3D printing.

See [bitclock-enclosure/](bitclock-enclosure/)

## PCB

KiCad schematic, board, and JLCPCB ordering files.

See [bitclock-pcb/](bitclock-pcb/)

# Blog posts

- [Advanced ESP32 development with ESP-IDF](https://bitclock.io/blog/esp-idf-vscode)

# Contributing

## Cloning the repo

This repo uses git submodules. Make sure to use `git clone --recursive`.

```sh
git clone --recursive git@github.com:goat-hill/bitclock.git
```

If the repo was previously checked out without `--recursive`, initialize the submodules.

```sh
git submodule init
git submodule update
```

## Pre-commit linting

A single pre-commit config is created for this monorepo. Set up the hooks to get linting on every commit.

```fish
brew install pre-commit
pre-commit install
```

## KiCad design bitclock-pcb/rev3a/kicad/canary.kicad_pcb

File bitclock-pcb/README.md:

# bitclock PCB

Each directory includes gerber + BOM files used for ordering from a PCBA service like JLCPCB.

Latest PCB version is [rev3a](rev3a/)

## PCBA ordering scripts

Used for ordering from JLCPCB or MacroFab.

https://github.com/goat-hill/kicad-pcba-scripts

## Revision history

#### rev3a
First version sold on https://bitclock.io/

It does include a few extraneous components that were an attempt to support the unreleased [BMV080](https://www.bosch-sensortec.com/products/environmental-sensors/particulate-matter-sensor/bmv080/) particulate sensor. I may have misinterpreted the preliminary datasheet so feel free to omit that connector and supporting capacitors. It also designs for an option side-USB port that I may omit in the future due to added routing complexity and it is unused.

Parts:
C1, C2: 1µF; C_0402_1005Metric; JLCPCB Part # C52923
C3: 2.2µF; C_0603_1608Metric; JLCPCB Part # C23630
C4: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C5: 10µF; C_0603_1608Metric; JLCPCB Part # C96446
C7: 10pF; C_0402_1005Metric; JLCPCB Part # C32949
D1: KT-0603R; LED_0603_1608Metric; JLCPCB Part # C2286; not fitted
D2: 19-213/Y2C-CQ2R2L/3T(CY); LED_0603_1608Metric; JLCPCB Part # C72038; not fitted
R1, R12: 10kΩ; R_0402_1005Metric; JLCPCB Part # C25744
R2: 1k; R_0402_1005Metric; JLCPCB Part # C11702; not fitted
R3: 470R; R_0402_1005Metric; JLCPCB Part # C25117; not fitted
R4, R5: 5.1kΩ; R_0402_1005Metric; JLCPCB Part # C25905
SW1, SW2: SW_Push; SW_Push_1P1T_XKB_TS-1187A; JLCPCB Part # C318884
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13: TestPoint; TestPoint_Pad_D1.5mm
U1: TLV76733DRVT; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; JLCPCB Part # C2867572
U2: ESP32-S3-WROOM-1-N8; ESP32-S3-WROOM-1; JLCPCB Part # C2913198

Connections:
+3.3V: C3.2, C4.1, C5.1, R1.1, R3.1, R4.2, R5.2, R12.2, TP2.1, U1.1 (OUT), U1.2 (SNS), U2.2 (3V3); also elsewhere on the board
+5V: C1.2, R2.1, TP1.1, U1.4 (EN), U1.6 (IN); also elsewhere on the board
/BMV_IRQ1: U2.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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); also elsewhere on the board
/BMV_IRQ2: U2.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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); also elsewhere on the board
/BOOT: C7.1, R12.1, SW2.1, U2.27 (GPIO0/BOOT)
/CHIP_EN: C2.1, R1.2, SW1.1, U2.3 (EN)
/D+: TP6.1, U2.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+); also elsewhere on the board
/D-: TP7.1, U2.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-); also elsewhere on the board
/D_BUSY_N: U2.4 (GPIO4/TOUCH4/ADC1_CH3); also elsewhere on the board
/D_DC: TP10.1, U2.7 (GPIO7/TOUCH7/ADC1_CH6); also elsewhere on the board
/D_RST_N: U2.5 (GPIO5/TOUCH5/ADC1_CH4); also elsewhere on the board
/I2C_SCL: R5.1, TP5.1, U2.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD); also elsewhere on the board
/I2C_SDA: R4.1, TP4.1, U2.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1); also elsewhere on the board
/LED_R: D1.2 (A), R2.2
/LED_Y: D2.2 (A), R3.2
/SPI_CS_BMV: TP8.1, U2.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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); also elsewhere on the board
/SPI_CS_DISP: TP9.1, U2.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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); also elsewhere on the board
/SPI_MISO: TP13.1, U2.38 (GPIO2/TOUCH2/ADC1_CH1); also elsewhere on the board
/SPI_MOSI: TP12.1, U2.39 (GPIO1/TOUCH1/ADC1_CH0); also elsewhere on the board
/SPI_SCL: TP11.1, U2.6 (GPIO6/TOUCH6/ADC1_CH5); also elsewhere on the board
GND: C1.1, C2.2, C3.1, C4.2, C5.2, C7.2, D1.1 (K), D2.1 (K), SW1.2, SW2.2, TP3.1, U1.3 (GND), U1.5 (GND), U1.7 (PAD), U2.1 (GND), U2.40 (GND), U2.41 (GND); also elsewhere on the board

Notes on the sheet:
ERC Hacks
Boot button
Boot pull-up
Chip enable delay
3V3 LED
Reset button
Power LED
Testpoints
ESP32
Linear regulator (LDO) 5v -> 3v3

Parts:
C26, C27: 22pF; C_0402_1005Metric; not fitted
D6, D7, D8: LESD5D5.0CT1G; D_SOD-523; JLCPCB Part # C383211
D9: 1N5819HW-7-F; D_SOD-123; JLCPCB Part # C82544
J3: TYPE-C16PIN; USB-C-SMD_TYPE-C16PIN; LCSC Part C393939; not fitted
J4: TYPE-C 16PLC-H10.0; TYPE-C-TH_16PLC-H10.0; LCSC Part C3151747
R8, R9: 5.1kΩ; R_0402_1005Metric; JLCPCB Part # C25905
R10, R11: 0Ω; R_0402_1005Metric; JLCPCB Part # C17168

Connections:
+5V: D9.1 (K); also elsewhere on the board
/D+: C26.1, R10.2; also elsewhere on the board
/D-: C27.1, R11.2; also elsewhere on the board
/USB/CC1: J3.A5 (CC1), J4.A5 (CC1), R8.1
/USB/CC2: J3.B5 (CC2), J4.B5 (CC2), R9.1
/USB/USB_D+: D7.1 (A1), J3.A6 (DP1), J3.B6 (DP2), J4.A6 (D+), J4.B6 (D+), R10.1
/USB/USB_D-: D8.1 (A1), J3.A7 (DN1), J3.B7 (DN2), J4.A7 (D-), J4.B7 (D-), R11.1
GND: C26.2, C27.2, D6.2 (A2), D7.2 (A2), D8.2 (A2), J3.1 (SHELL), J3.2 (SHELL), J3.3 (SHELL), J3.4 (SHELL), J3.A1B12 (GND), J3.B1A12 (GND), J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), R8.2, R9.2; also elsewhere on the board
VBUS: D6.1 (A1), D9.2 (A), J3.A4B9 (VBUS), J3.B4A9 (VBUS), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)

Notes on the sheet:
ERC Hacks
Right angle USB-C port
Vertical USB-C port
ESD Protection
USB to GPIO
USB upstream facing pull-down

Parts:
C8: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C9, C11, C12, C13, C14, C15, C16, C17: 1µF; C_0402_1005Metric; JLCPCB Part # C52923
C10: 4.7µF; C_0603_1608Metric; JLCPCB Part # C19666
D3, D4, D5: 1N5819HW-7-F; D_SOD-123; JLCPCB Part # C82544
J1: FH34SRJ-24S-0.5SH; HRS_FH34SRJ-24S-0.5SH_99_; PARTREV NA; JLCPCB Part # C324726
L1: 600mA 10uH ±20% SPH3010H100MT; L_Sunlord_SWPA3010S; JLCPCB Part # C279861
Q1: AO3400A; SOT-23; JLCPCB Part # C20917
R6: 470mΩ; R_0402_1005Metric; JLCPCB Part # C158958

Connections:
+3.3V: C8.1, C9.1, J1.15 (VDDIO), J1.16 (VDD), L1.1; also elsewhere on the board
/D_BUSY_N: J1.9 (BUSY_N); also elsewhere on the board
/D_DC: J1.11 (DC); also elsewhere on the board
/D_RST_N: J1.10 (RST_N); also elsewhere on the board
/Display Port/D_GDR: J1.2 (GDR), Q1.1 (G)
/Display Port/D_RESE: J1.3 (RESE), Q1.2 (S), R6.1
/Display Port/D_VCOM: C12.1, J1.24 (VCOM)
/Display Port/D_VDDD: C17.1, J1.18 (VDDD)
/Display Port/D_VDH: C16.1, J1.20 (VDH)
/Display Port/D_VDHR: C11.1, J1.5 (VDHR)
/Display Port/D_VDL: C14.1, J1.22 (VDL)
/Display Port/D_VGH: C15.1, D5.1 (K), J1.21 (VGH)
/Display Port/D_VGH_BD: C10.1, D5.2 (A), L1.2, Q1.3 (D)
/Display Port/D_VGL: C13.1, D4.2 (A), J1.23 (VGL)
/Display Port/D_VGL_PD: C10.2, D3.2 (A), D4.1 (K)
/SPI_CS_DISP: J1.12 (CSB); also elsewhere on the board
/SPI_MOSI: J1.14 (SDA); also elsewhere on the board
/SPI_SCL: J1.13 (SCL); also elsewhere on the board
GND: C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D3.1 (K), J1.8 (BS), J1.17 (GND), J1.S (SHIELD), R6.2; also elsewhere on the board

Parts:
C18: 10µF; C_0603_1608Metric; JLCPCB Part # C96446
C19: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C20, C21, C22, C23, C24, C25: 1µF; C_0402_1005Metric; JLCPCB Part # C52923
J2: ECT818001568; FPC-SMD_ECT818001568; LCSC Part C711417
R7: 4.7Ω; R_0603_1608Metric; JLCPCB Part # C23164
U3: SGP41-D-R4; XDCR_SGP41-D-R4; PARTREV 1.0; JLCPCB Part # C3659325
U4: SCD40-D-R2; Sensirion_SCD4x-1EP_10.1x10.1mm_P1.25mm_EP4.8x4.8mm; JLCPCB Part # C3659421
U5: SHT40-AD1B-R2; Sensirion_DFN-4_1.5x1.5mm_P0.8mm_SHT4x_NoCentralPad; JLCPCB Part # C2909890

Connections:
+3.3V: C18.1, C19.2, C21.1, C22.2, C23.2, C24.2, C25.2, J2.1 (VDDL), J2.3 (VDDA), J2.8 (VDDIO), J2.10 (VDDD), R7.1, U3.5 (VDDH), U4.7 (VDD), U4.19 (VDD), U5.3 (VDD); also elsewhere on the board
/BMV_IRQ1: J2.13 (IRQ1); also elsewhere on the board
/BMV_IRQ2: J2.12 (IRQ2); also elsewhere on the board
/I2C_SCL: U3.6 (SCL), U4.9 (SCL), U5.2 (SCL); also elsewhere on the board
/I2C_SDA: U3.3 (SDA), U4.10 (SDA), U5.1 (SDA); also elsewhere on the board
/SPI_CS_BMV: J2.4 (CSB); also elsewhere on the board
/SPI_MISO: J2.11 (MISO); also elsewhere on the board
/SPI_MOSI: J2.5 (MOSI); also elsewhere on the board
/SPI_SCL: J2.6 (SCK); also elsewhere on the board
/Sensors/SGP4X_VDD: C20.1, R7.2, U3.1 (VDD)
GND: C18.2, C19.1, C20.2, C21.2, C22.1, C23.1, C24.1, C25.1, J2.2 (VSSA), J2.7 (PS), J2.9 (VSSD), J2.14 (SHELL), J2.15 (SHELL), U3.2 (VSS), U3.4 (N/A), U3.7 (EXP), U4.6 (GND), U4.20 (GND), U4.21 (GND), U5.4 (VSS); also elsewhere on the board

Notes on the sheet:
VOC sensor
Temp + humidity sensor
CO2 sensor

Board: 4 copper layers, 78.0 x 48.0 mm, 74 parts (1 on the bottom side), 38 nets.

Other parts of the board:
EINK1: EInk_Display_2.71_E2271KS0C1

File bitclock-pcb/rev3a/order/bom-jlcpcb.csv:

Comment,Designator,Footprint,JLCPCB Part #
TestPoint,"TP1,TP2,TP3,TP4,TP5,TP6,TP7,TP8,TP9,TP10,TP11,TP12,TP13",TestPoint_Pad_D1.5mm,
100nF,"C4,C8,C19",C_0402_1005Metric,C1525
0Ω,"R10,R11",R_0402_1005Metric,C17168
4.7µF,C10,C_0603_1608Metric,C19666
AO3400A,Q1,SOT-23,C20917
4.7Ω,R7,R_0603_1608Metric,C23164
2.2µF,C3,C_0603_1608Metric,C23630
10kΩ,"R1,R12",R_0402_1005Metric,C25744
5.1kΩ,"R4,R5,R8,R9",R_0402_1005Metric,C25905
10pF,C7,C_0402_1005Metric,C32949
1µF,"C1,C2,C9,C11,C12,C13,C14,C15,C16,C17,C20,C21,C22,C23,C24,C25",C_0402_1005Metric,C52923
1N5819HW-7-F,"D3,D4,D5,D9",D_SOD-123,C82544
10µF,"C5,C18",C_0603_1608Metric,C96446
470mΩ,R6,R_0402_1005Metric,C158958
600mA 10uH ±20% SPH3010H100MT,L1,L_Sunlord_SWPA3010S,C279861
SW_Push,"SW1,SW2",SW_Push_1P1T_XKB_TS-1187A,C318884
FH34SRJ-24S-0.5SH,J1,HRS_FH34SRJ-24S-0.5SH_99_,C324726
LESD5D5.0CT1G,"D6,D7,D8",D_SOD-523,C383211
ECT818001568,J2,FPC-SMD_ECT818001568,C711417
TLV76733DRVT,U1,WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm,C2867572
SHT40-AD1B-R2,U5,Sensirion_DFN-4_1.5x1.5mm_P0.8mm_SHT4x_NoCentralPad,C2909890
ESP32-S3-WROOM-1-N8,U2,ESP32-S3-WROOM-1,C2913198
TYPE-C 16PLC-H10.0,J4,TYPE-C-TH_16PLC-H10.0,C3151747
SGP41-D-R4,U3,XDCR_SGP41-D-R4,C3659325
SCD40-D-R2,U4,Sensirion_SCD4x-1EP_10.1x10.1mm_P1.25mm_EP4.8x4.8mm,C3659421

## Commit log (part)

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2024-06-12 build update
2024-06-12 temp favicon
2024-06-12 remove unused
2024-06-13 update enclosure
2024-06-13 version update
2024-06-13 Add form
2024-06-13 hack
2024-06-13 fix breadboard demo
2024-06-13 disable round for demo
2024-06-14 modify copy
2024-06-14 lint
2024-06-17 demo mode
2024-06-18 less sensitive voc alert
2024-07-10 progress
    progress
    progress
2024-07-10 progress
2024-07-11 Fix callback domain
2024-07-11 Highlight IoT
2024-07-11 fix part id
2024-07-11 boot branding
2024-07-11 Read serial number
2024-07-11 Debug line
2024-07-16 Pause orders
2024-07-25 Revert "Pause orders"
    This reverts commit 62e89eba9ca2443044789f666244704f1ba07ec7.
2024-07-25 Improve sht4x comms
2024-07-25 price update due to increased manufacturing costs :(
2024-07-31 improve startup time
2024-07-31 esp idf 5.3.0
2024-07-31 heat attempt
2024-07-31 more heat
2024-08-04 Compensate RH values
2024-08-04 Trim values last
2024-08-05 image update
2024-08-12 open source rev3a PCB
2024-08-14 social media image
2024-08-14 Update README.md
    Better indicate how to get it
2024-08-15 update sensor accuracy FAQ
2024-09-05 Add time to top right of weather view
2024-09-10 Add instruction for removing protective film
2024-09-16 simplify
2024-09-19 udpate
2024-09-28 air quality UI
2024-09-28 tweaks
2024-10-17 show time in weather view
2024-10-17 fix font and alignment
2024-11-28 wip
    Update eink_display.c
    wip2
    Update mqtt.c
    Update mqtt.c
    Update mqtt.c
    rename
2024-11-28 Attempt to add web changes
2024-11-30 Fixes
2024-11-30 Fix delay
2024-11-30 Fix snprintf
2024-11-30 Fix web
2024-11-30 fix string formatting
2024-11-30 fix double percent
2024-12-01 Add state_topic, use abbreviations
2024-12-01 remove units
2024-12-01 update to latest esp idf
2024-12-01 regen sdk config
2024-12-01 fix task name
2024-12-01 Free up RAM
2024-12-01 Give clearer task names
2024-12-01 Reduce task RAM usage
2024-12-01 Reduce heap size from SSL
2024-12-01 Debugging code for heap usage
2025-06-01 esp-idf auto updates
2025-06-10 Weather API
2025-06-10 Fix API link
2025-06-23 web update
2025-06-23 typescript hack
2025-10-27 update idf, linux case sensitive filesystem fix
2025-10-27 Bump next from 14.2.30 to 14.2.33 in /bitclock-web
    Bumps [next](https://github.com/vercel/next.js) from 14.2.30 to 14.2.33.
    - [Release notes](https://github.com/vercel/next.js/releases)
    - [Changelog](https://github.com/vercel/next.js/blob/canary/release.js)
    - [Commits](https://github.com/vercel/next.js/compare/v14.2.30...v14.2.33)
    ---
    updated-dependencies:
2025-10-27 weather api fix
2025-10-27 precommit fixes
2025-10-27 Add firmware bluetooth attribute
2025-10-28 Fix weather label comparisons
2025-10-28 gatt attribute
2025-10-28 weather api improvements
2025-10-28 more robust icon matching
2025-10-29 fuzzy matching instead...
2025-10-29 version 1.1.1
2025-10-30 reduce heap usage
2025-10-30 add negative
2025-10-30 fix pairing font size
2025-12-16 Always show co2 ppm
